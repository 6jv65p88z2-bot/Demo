# Keil uVision project Marlin_AT32.uvprojx, settings and files
target Marlin_AT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x18000000) IROM(0x08000000,0x40000000F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Marlin_AT32 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=1
  c define: AT32F435VGT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\delay;..\fatfs\source;..\marlin;..\marlin\marlin_core;..\marlin\marlin_gcode;..\marlin\marlin_lcd;..\marlin\marlin_msc;..\marlin\marlin_module
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\Marlin_AT32.sct
  group user
    ../user/: main.c Delay.c wk_usart.c wk_system.c at32f435_437_wk_config.c at32f435_437_int.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_ertc.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_edma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_crc.c at32f435_437_wwdt.c at32f435_437_wdt.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_can.c at32f435_437_dac.c at32f435_437_xmc.c at32f435_437_qspi.c at32f435_437_sdio.c at32f435_437_dvp.c at32f435_437_emac.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
